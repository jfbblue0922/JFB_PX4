## src/drivers/imu/st/asm330/Kconfig
```kconfig
menuconfig DRIVERS_IMU_ST_ASM330
	bool "asm330"
	default n
	---help---
		Enable support for asm330
```
