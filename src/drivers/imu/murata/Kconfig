## src/drivers/imu/murata/Kconfig
```kconfig
menuconfig DRIVERS_IMU_MURATA_SCHA63T
	bool "murata scha63t"
	default n
	---help---
		Enable support for murata scha63t
```
